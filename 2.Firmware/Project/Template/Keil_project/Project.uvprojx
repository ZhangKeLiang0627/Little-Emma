# Keil uVision project Project.uvprojx, settings and files
target GD32F30X_CL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F307VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.0
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL
  c include: ..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32F30x\Include;..\..\Firmware\GD32F30x_standard_peripheral\Include;..\..\Utilities;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../: gd32f30x_it.c main.c systick.c
  group CMSIS
    ../../../Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ../../../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ../../../Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group Doc
    ../: readme.txt
  group Hardware
    ../../../Hardware/Key/: Key.c Key.h
    ../../../Hardware/Random/: Random.c Random.h
    ../../../Hardware/OLED/: oled.c oled.h oledfont.h
    ../../../Hardware/BEEPER/: BEEPER.c BEEPER.h
    ../../../Hardware/Encoder/: Encoder.c Encoder.h
    ../../../Hardware/MPU6050/: inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h mpu6050.c mpu6050.h myiic.c myiic.h
    ../../../Hardware/W25QXX/: w25qxx.c w25qxx.h
    ../../../Hardware/SD/: MMC_SD.C mmc_sd.h
    ../../../Hardware/LED/: led.c led.h
    ../../../Hardware/MySPI/: MySPI.c MySPI.h
    ../../../Hardware/FileSystem/: FileSystem.c FileSystem.h
  group SYSTEM
    ../../../SYSTEM/: sys.c sys.h TIMER5_Delay.c TIMER5_Delay.h Queue.c Queue.h UART0.c UART0.h
  group OLED_U8G2
    ../../../Hardware/OLED_U8G2/: u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_Init.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_a2printer.c u8x8_d_ssd1306_128x32.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c mui.c mui.h mui_u8g2.c mui_u8g2.h u8g2.h u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_Init.h u8x8.h
  group HugoUI
    ../../../Hardware/Hugo_UI/: Hugo_UI.c Hugo_UI.h HugoUI_User.c HugoUI_User.h HugoUI_BMP.c HugoUI_BMP.h
    ../../../Hardware/OLED/: OLED_User.c OLED_User.h
  group MALLOC
    ../../../MALLOC/: malloc.c malloc.h
  group FATFS
    ../../../FATFS/src/: diskio.c ff.c
    ../../../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../../../TEXT/: fontupd.c text.c
  group DSP_LIB
    ../../../DSP_LIB/: arm_cortexM4lf_math.lib
  group MAX30102
    ../../../Hardware/MAX30102/: max30102.c max30102.h max30102_fir.c max30102_fir.h myiic_max30102.c myiic_max30102.h max3010x.c max3010x.h algorithm.c algorithm.h
target GD32F30X_XD (ARM-ADS)
  device: GD32F303RK GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.0
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_XD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x18000
target GD32F30X_HD (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,ARM_MATH_CM4,__FPU_PRESENT,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\..\..\Firmware\CMSIS;..\..\..\Firmware\CMSIS\GD\GD32F30x\Include;..\..\..\Firmware\GD32F30x_standard_peripheral\Include;..\..\Template;..\..\..\Firmware\GD32F30x_standard_peripheral\Source;..\..\..\Firmware\CMSIS\GD\GD32F30x\Source\ARM;..\..\..\Hardware\Grammar;..\..\..\Hardware\OLED;..\..\..\Hardware\GUI;..\..\..\Hardware\Key;..\..\..\Hardware\OLED_U8G2;..\..\..\Hardware\Random;..\..\..\SYSTEM;..\..\..\Hardware\DataType;..\..\..\Hardware\BEEPER;..\..\..\Hardware\Encoder;..\..\..\Hardware\Hugo_UI;..\..\..\Hardware\MPU6050;..\..\..\Hardware\LED;..\..\..\Hardware\W25QXX;..\..\..\Hardware\SD;..\..\..\FATFS\src;..\..\..\FATFS\exfuns;..\..\..\Hardware\MySPI;..\..\..\MALLOC;..\..\..\Hardware\FileSystem;..\..\..\TEXT;..\..\..\DSP_LIB;..\..\..\DSP_LIB\Include;..\..\..\Hardware\MAX30102
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1
